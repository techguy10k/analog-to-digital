# Keil uVision project pro.uvproj, settings and files
target PRO (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: pro +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: USE_UART1_AS_COMMAND_CONSOLE
  c include: .\lib.h;.\user\h
  group PRO
    ./: STARTUP.A51
    ./user/c/: pro.c IAP15W4K32S4_IT.c user_timer.c command.c
    ./lib.c/: uart.c eeprom.c delay.c io.c adc.c mt8880.c exint.c sort.c x9c104.c
